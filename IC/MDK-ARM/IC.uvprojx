# Keil uVision project IC.uvprojx, settings and files
target IC (6190000::V6.19::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ic +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32F746xx, ROOM_THERMOSTAT, APPLICATION, USE_DEBUGGER
  c misc: -Iscatter_file_path
  c include: ..\Inc;..\..\Common;..\..\Drivers\STM32F7xx\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\STM32F7xx\BSP\STM32F746;..\..\Drivers\STM32F7xx\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\STM32F7xx\BSP\Components;..\..\Middlewares\STemWin\inc;..\..\Middlewares\STemWin\png;..\..\Middlewares\TinyFrame;..\..\Middlewares\LuxNET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Run\db.sct
  group Icons
    ../Src/Display/: SijalicaOff.c SijalicaOn.c Termometar.c blindMedium.c next.c alHamliQR.c previous.c wifi.c mobilePhone.c colorSpectrum.c blackWhiteGradient.c icons_lights_ceiling_led_fixture_off.c icons_lights_ceiling_led_fixture_on.c icons_lights_chandelier_off.c icons_lights_chandelier_on.c icons_lights_hanging_off.c icons_lights_hanging_on.c icons_lights_led_off.c icons_lights_led_on.c icons_lights_spot_console_off.c icons_lights_spot_console_on.c icons_lights_spot_single_off.c icons_lights_spot_single_on.c icons_lights_stairs_off.c icons_lights_stairs_on.c icons_lights_wall_off.c icons_lights_wall_on.c icons_settings.c icons_security_sos.c icons_language_bos.c icons_language_eng.c icons_scene_dinner.c icons_scene_gathering.c icons_scene_leaving.c icons_scene_morning.c icons_scene_movie.c icons_scene_reading.c icons_scene_relaxing.c icons_scene_security.c icons_scene_sleep.c icons_scene_wizzard.c icons_menu_gate.c icons_menu_timers.c icons_scene_homecoming.c icons_toggle_on.c icons_toogle_off.c icons_date_time.c icons_button_down.c icons_button_fast_forward.c icons_button_fast_reverse.c icons_button_left.c icons_button_right.c icons_button_up.c icons_button_cancel.c icons_button_ok.c icons_button_reset.c icons_button_cancel_50_squared.c icons_button_save_50_squared.c icons_button_select_40_sqaured.c icons_alarm_20.c icons_cooling_20.c icons_heating_20.c icons_cooling_20_activ.c icons_heating_20_activ.c icons_gate_garage_door_closed.c icons_gate_garage_door_open.c icons_gate_garage_door_partial_open.c icons_gate_pedestrian_closed.c icons_gate_pedestrian_open.c icons_gate_ramp_closed.c icons_gate_ramp_open.c icons_gate_ramp_partial_open.c icons_gate_swing_gate_closed.c icons_gate_swing_gate_open.c icons_gate_swing_gate_partial_open.c icons_gate_sliding_gate_closed.c icons_gate_sliding_gate_open.c icons_gate_sliding_gate_partial_open.c icons_button_down_50_squared.c icons_button_fast_forward_50_squared.c icons_button_fast_reverse_50_squared.c icons_button_left_50_squared.c icons_button_right_50_squared.c icons_toggle_on_50_squared.c icons_toogle_off_50_squared.c icons_button_up_50_squared.c icons_gate_garage_door_closing.c icons_gate_garage_door_opening.c icons_gate_ramp_closing.c icons_gate_ramp_opening.c icons_gate_sliding_gate_closing.c icons_gate_sliding_gate_opening.c icons_gate_swing_gate_closing.c icons_gate_swing_gate_opening.c icons_menu_language_bhsc.c icons_menu_language_cze.c icons_menu_language_eng.c icons_menu_language_fra.c icons_menu_language_ger.c icons_menu_language_ita.c icons_menu_language_pol.c icons_menu_language_rus.c icons_menu_language_slo.c icons_menu_language_spa.c icons_menu_language_ukr.c icons_menu_defroster_off.c icons_menu_defroster_on.c icons_menu_ventilator_off.c icons_menu_ventilator_on.c icons_menu_theme.c icons_menu_clean.c icons_menu_all_off.c icons_menu_outdoor_lihts_off.c icons_menu_outdoor_lihts_on.c
  group Fonts
    ../Src/Display/: Verdana16_LAT.c Verdana20_LAT.c Verdana32_LAT.c
  group Animation
    ../Src/Display/: animation_welcome_frame_05.c animation_welcome_frame_10.c animation_welcome_frame_15.c animation_welcome_frame_20.c animation_welcome_frame_25.c animation_welcome_frame_30.c animation_welcome_frame_35.c animation_welcome_frame_40.c animation_welcome_frame_45.c animation_welcome_frame_50.c animation_welcome_frame_55.c animation_welcome_frame_60.c animation_welcome_frame_65.c animation_welcome_frame_70.c animation_welcome_frame_75.c animation_welcome_frame_80.c animation_welcome_frame_85.c animation_welcome_frame_90.c animation_welcome_frame_95.c animation_welcome_frame_100.c animation_welcome_frame_final.c animation_candle_frame_1.c animation_candle_frame_2.c animation_candle_frame_3.c animation_candle_frame_4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/HARDWARE
    ../../Drivers/STM32F7xx/BSP/Components/ft5336/: ft5336.c
    ../../Drivers/STM32F7xx/BSP/STM32F746/: stm32746g.c stm32746g_ts.c stm32746g_qspi.c stm32746g_sdram.c stm32746g_eeprom.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_usart.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2s.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_spi.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf.c LCDConf.c GUI_X.c
  group Middlewares/STemWin/PNG
    ../../Middlewares/STemWin/png/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c IMAGE_PNG.c infback.c inffast.c inftrees.c png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c inflate.c
  group Middlewares/STemWin/Lib
    ../../Middlewares/STemWin/Lib/: STemWin540_CM7_Keil.lib
  group Application/MDK-ARM
    ./Asm/: startup_stm32f746xx.s incl_gui_bmp.s
  group Application/User
    ../Src/: firmware_update_agent.c stm32f7xx_it.c thermostat.c ventilator.c defroster.c security.c curtain.c display.c buzzer.c lights.c scene.c rs485.c timer.c main.c gate.c
    ../../Middlewares/TinyFrame/: TinyFrame.c
    ../../Common/: common.c
software components: CMSIS:CORE 5.4.0
